common_imx.inc